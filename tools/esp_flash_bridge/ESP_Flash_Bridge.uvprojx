# Keil uVision project ESP_Flash_Bridge.uvprojx, settings and files
target ESP Flash Bridge (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ESP_Flash_Bridge +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\library;..\..\start;..\..\user
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group start
    ../../start/: core_cm3.c startup_stm32f10x_hd.s system_stm32f10x.c
  group bridge
    ./: bridge_main.c
  group library
    ../../library/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
